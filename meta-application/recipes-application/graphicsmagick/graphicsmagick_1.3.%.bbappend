PACKAGECONFIG += " bzip2 ttf jpeg jp2 lzma cpp tiff webp wmf"